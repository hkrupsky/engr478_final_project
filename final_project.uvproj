# Keil uVision project final_project.uvproj, settings and files
target final_project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: final_project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM
  c misc: --c99
  c include: ..\..;hal;drivers;utilities;.;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ./: final_project.c startup_rvmdk.S midi.h midi.c FreeRTOSConfig.h
    ./midifile/visual-studio/ExportMidi/: midi-tune.c
  group utilities
    ../../../../driverlib/rvmdk/: driverlib.lib
    ./utilities/: hw_gpio.h hw_types.h tm4c123gh6pm.h utilities.c hw_memmap.h Strings.c Strings.h
  group FreeRTOS
    ./FreeRTOS/: list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/MemMang/: heap_1.c
    ./FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group hal
    ./hal/: HAL_GPIO.c HAL_NVIC.c HAL_PLL.c HAL_PWM.c HAL.h HAL_GPIO.h HAL_NVIC.h HAL_PLL.h HAL_PWM.h
